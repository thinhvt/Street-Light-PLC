# IAR project Project.ewp, settings and files
configuration GP PLM ST7540 [BL-APP] (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\system; ..\inc; ..\PLMstack\inc; ..\STM32F10x_StdPeriph_Driver\inc; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\src\flashloader\NXP\FlashQN9080\chip_qn908x\cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: GP_PLM.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARMv6
    ../system/: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
    ./: stm32f10x_flash.icf
  group PLMstack_Driver
    ../PLMstack/src/: AES128.o stk_l.o stk_n.o stk_p.c stm32f10x_plm.c
  group Project
    ../src/: application.c comm.c dongle.c fwupdate.c iap.c usb.c user.c
    ../system/: main.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
