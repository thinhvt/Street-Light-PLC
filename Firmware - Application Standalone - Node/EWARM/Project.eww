<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BuildAll</name>
      <member>
        <project>Project</project>
        <configuration>BOOTLOADER</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>PLM_BL_APP</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


