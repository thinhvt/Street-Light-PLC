# IAR project Project.ewp, settings and files
configuration BOOTLOADER (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\system; ..\inc; ..\PLMstack\inc; ..\STM32F10x_StdPeriph_Driver\inc; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\src\flashloader\NXP\FlashQN9080\chip_qn908x\cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: BOOTLOADER.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../system/: startup_stm32f10x_md.s
  group EWARMv6
    ../system/: main.c stm32f10x_flash.c system_stm32f10x.c
    ./: stm32f10x_flash.icf
